# Keil uVision project arducleo_blink_led.uvproj, settings and files
target Nucleo_blink_led (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: arducleo_blink_led
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __MBED__=1, DEVICE_I2CSLAVE=1, TARGET_LIKE_MBED, DEVICE_PORTINOUT=1, __MBED_CMSIS_RTOS_CM, TARGET_STM32F1, DEVICE_RTC=1, TOOLCHAIN_object, __CMSIS_RTOS, DEVICE_CAN=0, TARGET_LIKE_CORTEX_M3, TARGET_CORTEX_M, ARM_MATH_CM3, TARGET_UVISOR_UNSUPPORTED, TARGET_M3, DEVICE_SERIAL=1, DEVICE_INTERRUPTIN=1, DEVICE_I2C=1, DEVICE_PORTOUT=1, __CORTEX_M3, DEVICE_STDIO_MESSAGES=1, TARGET_FF_MORPHO, TARGET_FF_ARDUINO, TARGET_RELEASE, TARGET_STM, DEVICE_PORTIN=1, DEVICE_SLEEP=1, TARGET_NUCLEO_F103RB, MBED_BUILD_TIMESTAMP=1469712098, DEVICE_SPI=1, TARGET_STM32F103RB, DEVICE_SPISLAVE=1, DEVICE_ANALOGIN=1, DEVICE_PWMOUT=1, TOOLCHAIN_ARM, TOOLCHAIN_ARM_STD, __ASSERT_MSG
  c misc: --restrict --multibyte_chars --apcs=interwork -c -O3 -Otime --brief_diagnostics -D__ASSERT_MSG --no_depend_system_headers --preinclude=../mbed_config.h --md --cpu=Cortex-M3 --split_sections --no_rtti --gnu
  c include: .;../../mbed_mdk/;../../mbed_mdk/TARGET_NUCLEO_F103RB;../../../mbed_mdk/TARGET_NUCLEO_F103RB/TARGET_STM;../../mbed_mdk/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1;../../mbed_mdk/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;../../mbed_mdk/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD
  asm misc: --cpreproc --cpreproc_opts=-D__MBED__=1,-DDEVICE_I2CSLAVE=1,-DTARGET_LIKE_MBED,-DDEVICE_PORTINOUT=1,-D__MBED_CMSIS_RTOS_CM,-DTARGET_STM32F1,-DDEVICE_RTC=1,-DTOOLCHAIN_object,-D__CMSIS_RTOS,-DDEVICE_CAN=1,-DTARGET_LIKE_CORTEX_M3,-DTARGET_CORTEX_M,-DARM_MATH_CM3,-DTARGET_UVISOR_UNSUPPORTED,-DTARGET_M3,-DDEVICE_SERIAL=1,-DDEVICE_INTERRUPTIN=1,-DDEVICE_I2C=1,-DDEVICE_PORTOUT=1,-D__CORTEX_M3,-DDEVICE_STDIO_MESSAGES=1,-DTARGET_FF_MORPHO,-DTARGET_FF_ARDUINO,-DTARGET_RELEASE,-DTARGET_STM,-DDEVICE_PORTIN=1,-DDEVICE_SLEEP=1,-DTARGET_NUCLEO_F103RB,-DMBED_BUILD_TIMESTAMP=1469712098,-DDEVICE_SPI=1,-DTARGET_STM32F103RB,-DDEVICE_SPISLAVE=1,-DDEVICE_ANALOGIN=1,-DDEVICE_PWMOUT=1,-DTOOLCHAIN_ARM,-DTOOLCHAIN_ARM_STD,-D__ASSERT_MSG
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ../../mbed_mdk/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD/stm32f103xb.sct
  group Source_Files
    ./: blink_main.cpp
  group mbed
    ../../mbed_mdk/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h PlatformMutex.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h SingletonPtr.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group mbed/TARGET_NUCLEO_F103RB
    ../../mbed_mdk/TARGET_NUCLEO_F103RB/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32f103xb.h stm32f1xx.h stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.h stm32f1xx_hal_conf.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_usb.h system_stm32f1xx.h
  group mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1
    ../../mbed_mdk/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/: common_objects.h gpio_object.h PeripheralPins.h
  group mbed/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB
    ../../mbed_mdk/TARGET_NUCLEO_F103RB/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
  group mbed/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD
    ../../mbed_mdk/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_STD/: cmsis_nvic.o hal_tick.o mbed.ar mbed_board.o mbed_overrides.o retarget.o startup_stm32f103xb.o stm32f1xx_hal.o stm32f1xx_hal_adc.o stm32f1xx_hal_adc_ex.o stm32f1xx_hal_can.o stm32f1xx_hal_cec.o stm32f1xx_hal_cortex.o stm32f1xx_hal_crc.o stm32f1xx_hal_dac.o stm32f1xx_hal_dac_ex.o stm32f1xx_hal_dma.o stm32f1xx_hal_eth.o stm32f1xx_hal_flash.o stm32f1xx_hal_flash_ex.o stm32f1xx_hal_gpio.o stm32f1xx_hal_gpio_ex.o stm32f1xx_hal_hcd.o stm32f1xx_hal_i2c.o stm32f1xx_hal_i2s.o stm32f1xx_hal_irda.o stm32f1xx_hal_iwdg.o stm32f1xx_hal_nand.o stm32f1xx_hal_nor.o stm32f1xx_hal_pccard.o stm32f1xx_hal_pcd.o stm32f1xx_hal_pcd_ex.o stm32f1xx_hal_pwr.o stm32f1xx_hal_rcc.o stm32f1xx_hal_rcc_ex.o stm32f1xx_hal_rtc.o stm32f1xx_hal_rtc_ex.o stm32f1xx_hal_sd.o stm32f1xx_hal_smartcard.o stm32f1xx_hal_spi.o stm32f1xx_hal_spi_ex.o stm32f1xx_hal_sram.o stm32f1xx_hal_tim.o stm32f1xx_hal_tim_ex.o stm32f1xx_hal_uart.o stm32f1xx_hal_usart.o stm32f1xx_hal_wwdg.o stm32f1xx_ll_fsmc.o stm32f1xx_ll_sdmmc.o stm32f1xx_ll_usb.o sys.o system_stm32f1xx.o
