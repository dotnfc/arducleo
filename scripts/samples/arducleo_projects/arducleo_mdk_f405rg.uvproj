# Keil uVision project arducleo_mdk_f405rg.uvproj, settings and files
target arducleo_f405rg (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: arducleo_sample_f405rg
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __MBED__=1, DEVICE_I2CSLAVE=1, TARGET_LIKE_MBED, TARGET_MTS_MDOT_F405RG, TARGET_RTOS_M4_M7, DEVICE_RTC=1, TOOLCHAIN_object, TARGET_STM32F4, __CMSIS_RTOS, DEVICE_STDIO_MESSAGES=1, TARGET_CORTEX_M, TARGET_LIKE_CORTEX_M4, TARGET_M4, TARGET_UVISOR_UNSUPPORTED, DEVICE_PWMOUT=1, DEVICE_INTERRUPTIN=1, DEVICE_I2C=1, DEVICE_PORTOUT=1, __CORTEX_M4, __MBED_CMSIS_RTOS_CM, TARGET_MTS_MDOT_F405RG, TARGET_FF_MORPHO, __FPU_PRESENT=1, TARGET_FF_ARDUINO, DEVICE_PORTIN=1, TARGET_RELEASE, TARGET_STM, DEVICE_SERIAL_FC=1, DEVICE_PORTINOUT=1, MBED_BUILD_TIMESTAMP=1471503888, DEVICE_SLEEP=1, DEVICE_SPI=1, TOOLCHAIN_ARM_STD, DEVICE_SPISLAVE=1, DEVICE_ANALOGIN=1, DEVICE_SERIAL=1, DEVICE_ERROR_RED=1, TOOLCHAIN_ARM, ARM_MATH_CM4, __ASSERT_MSG
  c misc: --restrict --multibyte_chars --apcs=interwork -c -O0 -Otime --brief_diagnostics --cpu=Cortex-M4.fp -D__ASSERT_MSG --no_depend_system_headers --preinclude=../mbed_config.h --md --split_sections --no_rtti --gnu
  c include: .; ../../mbed; ../../mbed/TARGET_MTS_MDOT_F405RG; ../../mbed/TARGET_MTS_MDOT_F405RG/TARGET_STM; ../../mbed/TARGET_MTS_MDOT_F405RG/TARGET_STM/TARGET_STM32F4; ../../mbed/TARGET_MTS_MDOT_F405RG/TARGET_STM/TARGET_STM32F4/TARGET_MTS_MDOT_F405RG; ../../mbed/TARGET_MTS_MDOT_F405RG/TOOLCHAIN_ARM_STD
  asm misc: --cpreproc --cpreproc_opts=-D__MBED__=1,-DDEVICE_I2CSLAVE=1,-DTARGET_LIKE_MBED,-DTARGET_MTS_MDOT_F405RG,-DTARGET_RTOS_M4_M7,-DDEVICE_RTC=1,-DTOOLCHAIN_object,-DTARGET_STM32F4,-D__CMSIS_RTOS,-DDEVICE_STDIO_MESSAGES=1,-DTARGET_CORTEX_M,-DTARGET_LIKE_CORTEX_M4,-DTARGET_M4,-DTARGET_UVISOR_UNSUPPORTED,-DDEVICE_PWMOUT=1,-DDEVICE_INTERRUPTIN=1,-DDEVICE_I2C=1,-DDEVICE_PORTOUT=1,-D__CORTEX_M4,-D__MBED_CMSIS_RTOS_CM,-DTARGET_MTS_MDOT_F405RG, -DTARGET_STM32F405RG, -DTARGET_FF_MORPHO,-D__FPU_PRESENT=1,-DTARGET_FF_ARDUINO,-DDEVICE_PORTIN=1,-DTARGET_RELEASE,-DTARGET_STM,-DDEVICE_SERIAL_FC=1,-DDEVICE_PORTINOUT=1,-DMBED_BUILD_TIMESTAMP=1471503888,-DDEVICE_SLEEP=1,-DDEVICE_SPI=1,-DTOOLCHAIN_ARM_STD,-DDEVICE_SPISLAVE=1,-DDEVICE_ANALOGIN=1,-DDEVICE_SERIAL=1,-DDEVICE_ERROR_RED=1,-DTOOLCHAIN_ARM,-DARM_MATH_CM4,-D__ASSERT_MSG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ../../mbed/TARGET_MTS_MDOT_F405RG/TOOLCHAIN_ARM_STD/stm32f405xx.sct
  group blink
    ../blink/: blink_main.cpp
  group display_time
    ../display_time/: display_time_main.cpp
  group i2c_master
    ../i2c_master/: i2c_master_main.cpp
  group printf
    ../printf/: printf_main.cpp
  group pwm1
    ../pwm1/: pwm1_main.cpp
  group pwm2
    ../pwm2/: pwm2_main.cpp
  group pwm3
    ../pwm3/: pwm3_main.cpp
  group pwm4_4mhz
    ../pwm4_4mhz/: pwm4_4mhz_main.cpp
  group pwm5_mario
    ../pwm5_mario/: pwm5_mario_main.cpp
  group pwm6_contra
    ../pwm6_contra/: pwm6_contra_main.cpp
  group read_analog_value
    ../read_analog_value/: read_analog_value_main.cpp
  group read_button
    ../read_button/: read_button_main.cpp
  group read_button_interrupt
    ../read_button_interrupt/: read_button_interrupt_main.cpp
  group sawtooth
    ../sawtooth/: sawtooth_main.cpp
  group sleep
    ../sleep/: sleep_main.cpp
  group spi_master
    ../spi_master/: spi_master_main.cpp
  group ticker
    ../ticker/: ticker_main.cpp
  group toggle_ios
    ../toggle_ios/: toggle_ios_main.cpp
  group welcome
    ../welcome/: welcome_main.cpp
  group mbed
    ../../mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h PlatformMutex.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h SingletonPtr.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group mbed/TARGET_MTS_MDOT_F405RG
    ../../mbed/TARGET_MTS_MDOT_F405RG/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32f405xx.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h system_stm32f4xx.h
  group mbed/TARGET_MTS_MDOT_F405RG/TARGET_STM/TARGET_STM32F4
    ../../mbed/TARGET_MTS_MDOT_F405RG/TARGET_STM/TARGET_STM32F4/: common_objects.h gpio_object.h PeripheralPins.h
  group mbed/TARGET_MTS_MDOT_F405RG/TARGET_STM/TARGET_STM32F4/TARGET_MTS_MDOT_F405RG
    ../../mbed/TARGET_MTS_MDOT_F405RG/TARGET_STM/TARGET_STM32F4/TARGET_MTS_MDOT_F405RG/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h PeripheralPins.c
  group mbed/TARGET_MTS_MDOT_F405RG/TOOLCHAIN_ARM_STD
    ../../mbed/TARGET_MTS_MDOT_F405RG/TOOLCHAIN_ARM_STD/: cmsis_nvic.o hal_tick.o mbed.ar mbed_board.o mbed_overrides.o retarget.o startup_stm32f405xx.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o sys.o system_stm32f4xx.o
